<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>gwncppvgb_msg_passer</key>
<param><key>id</key><value>gwncppvgb_msg_passer_0</value></param>
<param><key>tout_restart</key><value>8</value></param>
<param><key>tout_stop</key><value>4</value></param>
</block>
<block>
<key>gwncppvgb_msg_sink</key>
<param><key>id</key><value>gwncppvgb_msg_sink_0</value></param>
</block>
<block>
<key>gwncppvgb_msg_source</key>
<param><key>id</key><value>gwncppvgb_msg_source_0</value></param>
<param><key>msg_count</key><value>12</value></param>
<param><key>interval</key><value>1.0</value></param>
<param><key>payload</key><value>'Payload in message'</value></param>
</block>
<connection><source_block_id>gwncppvgb_msg_passer_0</source_block_id><sink_block_id>gwncppvgb_msg_sink_0</sink_block_id><source_key>out_port_0</source_key><sink_key>in_port_0</sink_key></connection>
<connection><source_block_id>gwncppvgb_msg_source_0</source_block_id><sink_block_id>gwncppvgb_msg_passer_0</sink_block_id><source_key>out_port_0</source_key><sink_key>in_port_0</sink_key></connection>
</flow_graph>
