<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>gwncppvgb_fsm_example</key>
<param><key>id</key><value>gwncppvgb_fsm_example_0</value></param>
<param><key>debug</key><value>False</value></param>
</block>
<block>
<key>gwncppvgb_symbol_strobe</key>
<param><key>id</key><value>gwncppvgb_symbol_strobe_0</value></param>
<param><key>count</key><value>19</value></param>
<param><key>period</key><value>1000</value></param>
<param><key>symbol_seq</key><value>sgxyrwrgrwrcrgrxys</value></param>
</block>
<connection><source_block_id>gwncppvgb_fsm_example_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>out_port_0</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>gwncppvgb_symbol_strobe_0</source_block_id><sink_block_id>gwncppvgb_fsm_example_0</sink_block_id><source_key>out_port_0</source_key><sink_key>in_port_0</sink_key></connection>
</flow_graph>
