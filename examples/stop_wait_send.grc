<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>gwncppvgb_data_source</key>
<param><key>id</key><value>gwncppvgb_data_source_0</value></param>
<param><key>count</key><value>10</value></param>
<param><key>payload</key><value>Data payload</value></param>
<param><key>period</key><value>1000.0</value></param>
<param><key>subtype</key><value>Data</value></param>
<param><key>type</key><value>Data</value></param>
</block>
<block>
<key>gwncppvgb_stop_wait_ack</key>
<param><key>id</key><value>gwncppvgb_stop_wait_ack_0</value></param>
</block>
<block>
<key>gwncppvgb_stop_wait_send</key>
<param><key>id</key><value>gwncppvgb_stop_wait_send_0</value></param>
<param><key>buf_len</key><value>5</value></param>
<param><key>fsm_debug</key><value>False</value></param>
<param><key>retries</key><value>5</value></param>
<param><key>timeout</key><value>300</value></param>
</block>
<block>
<key>gwncppvgb_virtual_channel</key>
<param><key>id</key><value>gwncppvgb_virtual_channel_0</value></param>
<param><key>prob_loss</key><value>0.5</value></param>
</block>
<connection><source_block_id>gwncppvgb_data_source_0</source_block_id><sink_block_id>gwncppvgb_stop_wait_send_0</sink_block_id><source_key>out_port_0</source_key><sink_key>in_port_0</sink_key></connection>
<connection><source_block_id>gwncppvgb_stop_wait_ack_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>out_port_0</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>gwncppvgb_stop_wait_ack_0</source_block_id><sink_block_id>gwncppvgb_stop_wait_send_0</sink_block_id><source_key>out_port_1</source_key><sink_key>in_port_0</sink_key></connection>
<connection><source_block_id>gwncppvgb_stop_wait_send_0</source_block_id><sink_block_id>gwncppvgb_virtual_channel_0</sink_block_id><source_key>out_port_0</source_key><sink_key>in_port_0</sink_key></connection>
<connection><source_block_id>gwncppvgb_virtual_channel_0</source_block_id><sink_block_id>gwncppvgb_stop_wait_ack_0</sink_block_id><source_key>out_port_0</source_key><sink_key>in_port_0</sink_key></connection>
</flow_graph>
